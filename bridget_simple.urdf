Commit message: shifted origin for scaled down stl file

File: bridget_simple.urdf (robot description, URDF)
Before this commit: robot artemis, 1 links, 0 joints
Links:
- link body: geometry collision box size=0.134879 0.255042 0.002; visual mesh filename=bridget_scaled_down.stl
